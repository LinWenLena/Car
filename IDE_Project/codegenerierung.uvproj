# Keil uVision project codegenerierung.uvproj, settings and files
target Debug (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: GettingStarted
  BeforeMake: java -jar "c:\Willert\MM_C_OORTX_Keil_ARM_MCB1700_TD_V6.01_beta\Tools\XMLCreator.jar" -sourceFolder "." -tool "Merapi" -destinationFile "./xmlData.xml" -targetConfigurationFile "c:\Willert\MM_C_OORTX_Keil_ARM_MCB1700_TD_V6.01_beta\Tools\Target.xml" -measureTime -subFolders
  AfterMake: cmd /c echo.>>WSTDeployer_CurrentFileList.txt
  c flags: Optim=1
  c include: .;GeneratedModel;RXF;Framework
  asm include: .;RXF;GeneratedModel
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: Keil-ARM-Startup.s
  group System
    ./: system_LPC17xx.c
  group Framework
    ./framework/: WST_Collection.h WST_SLinkedList.c WST_SLinkedList.h WST_Types.h GLCD.c GLCD.h
  group RXF
    ./RXF/: RxfConstants.h RxfDimensions.h WST.h WST_CFG.c WST_CFG.h WST_CON_LST.c WST_CON_LST.h WST_CON_LST_Entry.c WST_CON_LST_Entry.h WST_ERR.c WST_ERR.h WST_EVT.c WST_EVT.h WST_FSM.c WST_FSM.h WST_MEM.c WST_MEM.h WST_MEM_Pool.c WST_MEM_Pool.h WST_MSQ.c WST_MSQ.h WST_MTX.h WST_RXF.c WST_RXF.h WST_RXF_Main.c WST_TMM.c WST_TMM.h WST_TMR.c WST_TMR.h WSTCompiler.h WSTCompilerTypes.h WSTMemoryTypes.h WSTModelling.h WSTProduct.h WSTRTOS.c WSTRTOS.h WSTTarget.c WSTTarget.h WSTTypes.h WSTVersion.h
target Release (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: GettingStarted
  BeforeMake: as above
  AfterMake: cmd /c echo.>>WSTDeployer_CurrentFileList.txt
  c flags: Optim=1
  c include: .;GeneratedModel;RXF;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
